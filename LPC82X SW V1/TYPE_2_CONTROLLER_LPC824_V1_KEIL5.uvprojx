# Keil uVision project TYPE_2_CONTROLLER_LPC824_V1_KEIL5.uvprojx, settings and files
target LPC824 Flash (5060020::V5.06 (build 20)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TYPE_2_CONTROLLER_LPC824_V1_KEIL5 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: .\Library;.\Library\lpc_core;.\Library\lpc_core\lpc_chip;.\Library\lpc_core\lpc_chip\chip_8xx;.\Library\lpc_core\lpc_chip\chip_common;.\Library\lpc_core\lpc_chip\chip_8xx\config_82x;.\Library\lpc_core\lpc_board;.\Library\lpc_core\lpc_board\board_common;.\Library\lpc_core\lpc_board\boards_8xx\nxp_lpcxpresso_824
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Files
    ./Sources/: TYPE_2_CONTROLLER_LPC824_V1_KEIL5.c EV_UART.c EV_MOTOR.c EV_PWM.c SETTINGS.c EV_ADC.c EV_STATE_MACHINE.c
  group Library Files
    ./Library/: CLOCK_LPC82x.c GPIO_LPC82x.c SYSCON_LPC82x.c UART_LPC82x.c SWM_LPC82x.c IAP_LPC82x.c SCT_LPC82x.c ADC_LPC82x.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.0
